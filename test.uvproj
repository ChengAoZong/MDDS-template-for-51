# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: test
  c flags: Optimize=8 SizeSpeed=1
  c include: .\conf;..\..\MDDS\MDDS_51
  group Source Group 1
    ./: test.c STARTUP.A51
    ../../MDDS/: includes.c
    ./conf/: conf.h conf_app.h conf_driver.h conf_Math.h conf_middleware.h user_include.h userdef.h
